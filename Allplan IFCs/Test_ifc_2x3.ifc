Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: C:\Users\Eipm02\Desktop\Solibri\Test_ifc_2x3.ifc
Time: 2019-12-28T13:35:41
Author: Xavi Coll - EiPM
Organization: No Organization
Written by: EDMsix Version 2.0100.09 Sep 7 2016
Made in: Allplan 2020.0 11.12.2019 - 15:42:18

# IfcProject, BIM_1906_INCASOL_Test previs
AllplanAttributes - Client: Nom del Client / Promotor; Architect: Nom del tècnic signant del projecte; Construction project: PROJECTE PER A CÈDULA / LLICÈNCIA / REFORMA / OBRA NOVA; Architect, address: arquitecte / arquitecte tècnic; Address of construction project: Nom de la població; Construction project, street: Carrer, nº; Project number: 25100 / TC-1400 (número de referència de projecte de EiPM / BACHS); General construction project: AÏLLAT / ENTRE MITGERES; Construction project, name: LOCAL COMERCIAL / HABITATGE UNIFAMILIAR / HABITATGE PLURIFAMILIAR; Latitude: ATENCIÓ: respecteu majúscules, minúscules i separacions; Architect home page: ATENCIÓ: respecteu majúscules, minúscules i separacions; Client home page: ATENCIÓ: respecteu majúscules, minúscules i separacions; Construction project, home page: ATENCIÓ: respecteu majúscules, minúscules i separacions

# IfcSite, PROJECTE
RefLatitude: -48, 0, 0, 0; RefLongitude: 0, 0, 0, 0

# IfcBuildingStorey, P0
In: URB
Elevation: 0 mm

# IfcBeam: IFC ObjectSubtype_TEST (6)
In: P0
Description: Description_TEST
AllplanAttributes - Building alteration category: New building; Object_name: Object_name_TEST; Function: Function_TEST; Type: Type_TEST; Reference: Reference_TEST; type: type_TEST; Description: Description_TEST; Unit: m³
Name | Material = AllplanAttributes, Material | Trade | Name | Allright_Comp_ID | Reference
Name_SteelBeam_IPE 270 | Material_Steel | Steel construction work | Name_SteelBeam_IPE 270 | 1017Bea0000000048 | Code text_TEST_Structural_Framing_Steel | AllplanAttributes - Profile name: Profile name_IPE 270
Name_ConcreteBeam_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteBeam_Rect 30x30 | 1017Bea0000000046 | Code text_TEST_Structural_Framing_Concrete | AllplanAttributes - Profile name: Profile name_Rect 30x30
Name_ConcreteBeam_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteBeam_Rect 30x30 | 1017Bea0000000131 | Code text_TEST_Structural_Framing_Concrete
Name_SteelBeam_IPE 270 | Material_Steel | Steel construction work | Name_SteelBeam_IPE 270 | 1017Bea0000000132 | Code text_TEST_Structural_Framing_Steel
Name_SteelBeam_IPE 270 | Material_Steel | Steel construction work | Name_SteelBeam_IPE 270 | 1017Bea0000000109 | Code text_TEST_Structural_Framing_Steel
Name_ConcreteBeam_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteBeam_Rect 30x30 | 1017Bea0000000110 | Code text_TEST_Structural_Framing_Concrete

# IfcColumn: IFC ObjectSubtype_TEST (6)
In: P0
Description: Description_TEST
AllplanAttributes - Building alteration category: New building; Object_name: Object_name_TEST; Function: Function_TEST; Type: Type_TEST; Reference: Reference_TEST; type: type_TEST; Description: Description_TEST; Unit: m³
Name | Material = AllplanAttributes, Material | Trade | Name | Allright_Comp_ID | Reference
Name_SteelColumn_HEB 240 | Material_Steel | Steel construction work | Name_SteelColumn_HEB 240 | 1017Col0000000044 | Code text_TEST_Structural_Framing_Steel | AllplanAttributes - File name: C:\ProgramData\Nemetschek\Allplan\2020\Etc\Library\Engineering\Steel sections\2D profiles angular idealiz\HEB\HEB 240.sym; Sequence name: HEB 240; Profile name: Profile name_HEB 240
Name_ConcreteColumn_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteColumn_Rect 30x30 | 1017Col0000000130 | Code text_TEST_Structural_Framing_Concrete
Name_SteelColumn_HEB 240 | Material_Steel | Steel construction work | Name_SteelColumn_HEB 240 | 1017Col0000000134 | Code text_TEST_Structural_Framing_Steel | AllplanAttributes - File name: C:\ProgramData\Nemetschek\Allplan\2020\Etc\Library\Engineering\Steel sections\2D profiles angular idealiz\HEB\HEB 240.sym; Sequence name: HEB 240
Name_SteelColumn_HEB 240 | Material_Steel | Steel construction work | Name_SteelColumn_HEB 240 | 1017Col0000000108 | Code text_TEST_Structural_Framing_Steel | AllplanAttributes - File name: C:\ProgramData\Nemetschek\Allplan\2020\Etc\Library\Engineering\Steel sections\2D profiles angular idealiz\HEB\HEB 240.sym; Sequence name: HEB 240
Name_ConcreteColumn_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteColumn_Rect 30x30 | 1017Col0000000111 | Code text_TEST_Structural_Framing_Concrete
Name_ConcreteColumn_Rect 30x30 | Material_Concrete | Concreting work | Name_ConcreteColumn_Rect 30x30 | 1017Col0000000050 | Code text_TEST_Structural_Framing_Concrete | AllplanAttributes - Profile name: Profile name_Rect 30x30
